FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://ecm-crosscompile.patch"
